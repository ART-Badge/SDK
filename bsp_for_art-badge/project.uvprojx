# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  BeforeMake: .\libraries\tool\before_build_common.bat $K
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --gnu --preinclude mem_config.h  --preinclude app_define.h --bss_threshold=0  --diag_suppress=550  --diag_suppress=186
  c include: board\ADC;applications;.;board\mplayer;board\mplayer\player;board\mplayer\decode;board\mplayer\beep;packages\bsal-latest;packages\bsal-latest\inc;packages\bsal-latest\profiles\service\basl_bas;packages\bsal-latest\profiles\service\bsal_blufi;packages\bsal-latest\port\realtek;packages\online-packages\cJSON;rt-thread\components\cplusplus;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;board\DLPS;board;board\link_scripts;board\persim_port;board\mplayer;packages\online-packages\ezXML;packages\online-packages\fal\inc;ports\fal;packages\online-packages\fastlz;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;packages\online-packages\FlashDB\inc;packages\FlexibleButton-master;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\pthreads;packages\persim-packages\include;packages\realthread-packages\include;libraries\inc;libraries\inc\peripheral;libraries\inc\platform;libraries\inc\app;libraries\inc\os;libraries\inc\bluetooth\gap;libraries\inc\bluetooth\profile;libraries\inc\bluetooth\profile\server;libraries\src\app;libraries\src\app;libraries\src\app\wristband\spi_x_platform;libraries\src\app\wristband\gui_lib\include;libraries\src\app\wristband\lcd_driver;libraries\src\app\wristband\inc;libraries\src\ble;libraries\src\mcu;libraries\src\inc\peripheral;libraries\src\platform;libraries\bin\upperstack_img\upperstack_0_0;board\sc7a20;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;packages\smodule;packages\online-packages\thread_pool;packages\online-packages\SystemView;packages\online-packages\SystemView\SystemView_Src\Config;packages\online-packages\SystemView;packages\online-packages\SystemView\SystemView_Src\SEGGER;rt-thread\components\utilities\ulog;packages\online-packages\vconsole;.
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\link_scripts\link.sct
  group ADC
    board/ADC/: io_adc.c
  group Applications
    applications/: app_launch_cmd.c update_data.c main.c app_management_cmd.c mnt.c
  group beep
    board/mplayer/decode/: decode.c
    board/mplayer/: ringtones.c
    board/mplayer/beep/: beep.c
    board/mplayer/player/: player.c
  group bsal
    packages/bsal-latest/src/: bsal.c
    packages/bsal-latest/profiles/service/basl_bas/: bsal_srv_bas.c
    packages/bsal-latest/samples/: ble_bas_blufi_app.c
    packages/bsal-latest/port/realtek/: bsal_osif.c bsal_rtk.c
    packages/bsal-latest/profiles/service/bsal_blufi/: bsal_srv_blufi.c
  group cJSON
    packages/online-packages/cJSON/: cJSON_Utils.c cJSON.c cJSON_port.c
  group CPlusPlus
    rt-thread/components/cplusplus/: cxx_crt.cpp cxx_Mutex.cpp crt_init.c cxx_Semaphore.cpp cxx_Thread.cpp
  group CPU
    rt-thread/libcpu/arm/common/: showmem.c backtrace.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: rt_drv_pwm.c pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/rtc/: soft_rtc.c rtc.c alarm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: workqueue.c dataqueue.c completion.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c
    rt-thread/components/drivers/touch/: touch.c
  group DLSP
    board/DLPS/: dlps_app.c
  group Drivers
    board/: drv_gpio.c drv_flash.c osif_for_rtl876x.c drv_lcd_8080.c drv_pwm.c drv_i2c.c simulator_touch.c drv_touchpad.c drv_psram.c drv_usart.c drv_ble.c board.c
  group ezXML
    packages/online-packages/ezXML/: ezxml.c
  group fal
    packages/online-packages/fal/src/: fal_flash.c fal.c fal_partition.c fal_rtt.c
    ports/fal/: fal_init.c fal_flash_realtek.c
  group fastlz
    packages/online-packages/fastlz/: fastlz.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
    rt-thread/components/dfs/filesystems/romfs/: romfs.c dfs_romfs.c
  group finsh
    rt-thread/components/finsh/: shell.c msh_file.c msh.c cmd.c
  group FlashDB
    packages/online-packages/FlashDB/src/: fdb_tsdb.c fdb_cmd.c fdb_utils.c fdb.c fdb_kvdb.c fdb_file.c
  group flex_button
    packages/FlexibleButton-master/: flexible_button.c
  group Kernel
    rt-thread/src/: idle.c thread.c timer.c memheap.c scheduler.c object.c ipc.c device.c irq.c components.c mempool.c kservice.c clock.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: syscalls.c libc.c stdio.c mem_std.c
    rt-thread/components/libc/compilers/common/: time.c unistd.c stdlib.c
    rt-thread/components/libc/pthreads/: pthread.c pthread_attr.c pthread_cond.c semaphore.c pthread_mutex.c pthread_tls.c pthread_spin.c pthread_rwlock.c mqueue.c pthread_barrier.c sched.c
  group RTK_BSP
    libraries/src/app/wristband/module/: module_lcd_8080.c
    libraries/src/app/wristband/lcd_driver/: lcd_st7789_240.c
    libraries/src/app/wristband/SRC/: rtl876x_i2c_wristband.c
    libraries/src/ble/profile/server/: bas.c dis.c
    libraries/src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_adc.c rtl876x_uart.c rtl876x_pinmux.c rtl876x_rcc.c rtl876x_rtc.c rtl876x_nvic.c rtl876x_tim.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_if8080.c
    libraries/src/mcu/rtl876x/: system_rtl876x.c overlay_mgr.c
    libraries/src/mcu/rtl876x/arm/: startup_rtl876x.s
    libraries/src/platform/: psram_platform.c
  group RTK_LIB
    libraries/bin/: ROM.lib sbee2_sdk.lib adc.lib
    libraries/bin/upperstack_img/upperstack_0_0/: gap_utils.lib
  group sc7a20
    board/sc7a20/: sensor_sc7a20.c sc7a20.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor_cmd.c sensor.c
  group smodule
    packages/smodule/lib/: smodule.lib
  group thread_pool
    packages/online-packages/thread_pool/: thread_pool.c
  group trace
    packages/online-packages/SystemView/SystemView_Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
    packages/online-packages/SystemView/SystemView_Src/Config/: SEGGER_RTT_Device.c SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group vconsole
    packages/online-packages/vconsole/: vconsole.c
