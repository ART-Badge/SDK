# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  BeforeMake: before_build_special.bat
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: JERRY_ENABLE_LOGGING, JERRY_ENABLE_ERROR_MESSAGES, JMEM_STATS, CONFIG_DISABLE_ES2015, JERRY_ENABLE_EXTERNAL_CONTEXT, SUPPORT_ALONE_UPPERSTACK_IMG, FT2_BUILD_LIBRARY, RT_USING_ARM_LIBC, JERRY_JS_PARSER
  c misc: --gnu --preinclude mem_config.h  --preinclude app_define.h --bss_threshold=0  --diag_suppress=550  --diag_suppress=186
  c include: .;rt-thread\include;applications;.;board;board\link_scripts;libraries\bin\upperstack_img\upperstack_0_0;libraries\inc;libraries\inc\peripheral;libraries\inc\platform;libraries\inc\app;libraries\inc\os;libraries\inc\bluetooth\gap;libraries\inc\bluetooth\profile;libraries\inc\bluetooth\profile\server;libraries\src\app;libraries\src\app;libraries\src\app\wristband\spi_x_platform;libraries\src\app\wristband\gui_lib\include;libraries\src\app\wristband\lcd_driver;libraries\src\app\wristband\inc;libraries\src\ble;libraries\src\mcu;libraries\src\inc\peripheral;libraries\src\platform;packages\bsal-latest;packages\bsal-latest\inc;packages\bsal-latest\profiles\service\basl_bas;packages\bsal-latest\profiles\service\bsal_blufi;packages\bsal-latest\port\realtek;packages\cJSON-v1.0.2;packages\ezXML;packages\fal-v0.5.0\inc;ports\fal;packages\fastlz;packages\FlashDB\inc;packages\FlexibleButton-master;packages\mpu6xxx-v1.0.0\inc;packages\persim-packages\inc;packages\persim-packages\inc\persimmon\include;packages\persim-packages\inc\persimmon\widgets\QRCode;packages\persim-packages\inc\persimmon\widgets\BarCode;packages\persim-packages\inc\persimmon\local\include;packages\persim-packages\inc\gui\include;packages\persim-packages\inc\gui\libraries\lodepng;packages\persim-packages\inc\gui\libraries\prc\src;packages\persim-packages\inc\gui\libraries\freetype-2.6.2;..\..\..\..\..\src\autofit;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\base;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\cache;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\psnames;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\sfnt;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\smooth;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\src\truetype;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\include;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\include\freetype;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\include\freetype\config;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\include\freetype\internal;packages\persim-packages\inc\gui\libraries\freetype-2.6.2\include\freetype\internal\services;packages\persim-packages\inc\jerryscript;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\api;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\debugger;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\ecma\base;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\ecma\builtin-objects;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\ecma\builtin-objects\typedarray;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\ecma\operations;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\include;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\jcontext;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\jmem;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\jrt;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\lit;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\parser\js;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\parser\regexp;packages\persim-packages\inc\jerryscript\jerryscript\jerry-core\vm;packages\persim-packages\inc\jerryscript\jerryscript\jerry-ext\arg;packages\persim-packages\inc\jerryscript\jerryscript\jerry-ext\handler;packages\persim-packages\inc\jerryscript\jerryscript\jerry-ext\include;packages\persim-packages\inc\jerryscript\jerryscript\jerry-ext\module;packages\persim-packages\inc\jerryscript\rtthread-port;packages\persim-packages\inc\js_persimmon;packages\persim-packages\inc\vgl;packages\persimwear-js-fwk;.;packages\persimwear-js-fwk\base\cfgm;.;packages\persimwear-js-fwk\base\dcm;.;packages\persimwear-js-fwk\base\emq;.;packages\persimwear-js-fwk\module\hardware;.;packages\persimwear-js-fwk\module\sensor;.;packages\persimwear-js-fwk\module\storage;.;packages\persimwear-js-fwk\base\native;.;packages\realthread-packages\inc;packages\realthread-packages\inc\cfgm;.;packages\realthread-packages\inc\dcm\inc;packages\realthread-packages\inc\emq;.;packages\realthread-packages\inc\mcf\inc;packages\realthread-packages\inc\udbd;packages\realthread-packages\inc\urpc;packages\smodule\inc;packages\smodule\inc;packages\SystemView-latest;packages\SystemView-latest\SystemView_Src\Config;packages\SystemView-latest;packages\SystemView-latest\SystemView_Src\SEGGER;packages\thread_pool;packages\vconsole-v1.0.0;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\cplusplus;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;rt-thread\components\drivers\touch;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\pthreads;rt-thread\components\libc\time;rt-thread\components\utilities\ulog
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\link_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c app_launch_cmd.c app_management_cmd.c mnt.c
  group Drivers
    board/: board.c osif_for_rtl876x.c drv_usart.c drv_psram.c drv_lcd_8080.c drv_ble.c drv_gpio.c drv_i2c.c drv_touchpad.c simulator_touch.c drv_flash.c drv_pwm.c
  group RTK_LIB
    libraries/bin/: ROM.lib sbee2_sdk.lib
    libraries/bin/upperstack_img/upperstack_0_0/: gap_utils.lib
  group RTK_BSP
    libraries/src/app/wristband/lcd_driver/: lcd_st7789_240.c
    libraries/src/app/wristband/module/: module_lcd_8080.c
    libraries/src/app/wristband/SRC/: rtl876x_i2c_wristband.c
    libraries/src/ble/profile/server/: bas.c dis.c
    libraries/src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_gpio.c rtl876x_rtc.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_gdma.c rtl876x_tim.c rtl876x_if8080.c rtl876x_uart.c
    libraries/src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    libraries/src/mcu/rtl876x/arm/: startup_rtl876x.s
    libraries/src/platform/: psram_platform.c
  group bsal
    packages/bsal-latest/src/: bsal.c
    packages/bsal-latest/profiles/service/basl_bas/: bsal_srv_bas.c
    packages/bsal-latest/profiles/service/bsal_blufi/: bsal_srv_blufi.c
    packages/bsal-latest/samples/: ble_bas_blufi_app.c
    packages/bsal-latest/port/realtek/: bsal_rtk.c bsal_osif.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_realtek.c fal_init.c
  group fastlz
    packages/fastlz/: fastlz.c
  group FlashDB
    packages/FlashDB/src/: fdb.c fdb_cmd.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group flex_button
    packages/FlexibleButton-master/: flexible_button.c
  group mpu6xxx
    packages/mpu6xxx-v1.0.0/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group smodule
    packages/smodule/libs/: smodule.lib
  group trace
    packages/SystemView-latest/SystemView_Src/Config/: SEGGER_RTT_Device.c SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    packages/SystemView-latest/SystemView_Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group thread_pool
    packages/thread_pool/: thread_pool.c
  group vconsole
    packages/vconsole-v1.0.0/: vconsole.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group CPlusPlus
    rt-thread/components/cplusplus/: crt.cpp crt_init.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group Touch
    rt-thread/components/drivers/touch/: touch.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group pthreads
    rt-thread/components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    rt-thread/components/libc/time/: clock_time.c posix_sleep.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
